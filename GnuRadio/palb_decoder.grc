options:
  parameters:
    description: Enhanced PAL-B/G Video Decoder for HackRF
    generate_options: qt_gui
    id: palb_decoder
    output_language: python
    title: PAL-B/G Enhanced Decoder
  states: {}

blocks:
- name: audio_samp_rate
  id: variable
  parameters:
    value: 48e3
  states: {}
- name: audio_volume
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,4,1,1
    label: Audio Volume
    start: '0'
    step: '0.1'
    stop: '10'
    value: '1'
  states: {}
- name: bb_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2,1,1
    label: BB Gain
    start: '0'
    step: '1'
    stop: '40'
    value: '20'
  states: {}
- name: color_carrier
  id: variable
  parameters:
    value: 4.43361875e6
  states: {}
- name: demod_mode
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,3,1,1
    label: Video Demod
    label0: AM (VSB)
    label1: FM
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: freq
  id: variable
  parameters:
    value: 486e6
  states: {}
- name: if_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: IF Gain
    start: '0'
    step: '1'
    stop: '40'
    value: '20'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: RF Gain
    start: '0'
    step: '1'
    stop: '40'
    value: '20'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 16e6
  states: {}
- name: sound_carrier
  id: variable
  parameters:
    value: 5.5e6
  states: {}
- name: video_samp_rate
  id: variable
  parameters:
    value: 6e6
  states: {}
- name: analog_quadrature_demod_audio
  id: analog_quadrature_demod_cf
  parameters:
    comment: Audio FM Demod
    gain: samp_rate/(2*math.pi*50e3)
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    comment: FM Demod
    gain: samp_rate/(2*math.pi*5e6)
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: int(audio_samp_rate)
  states: {}
- name: band_pass_filter_audio
  id: band_pass_filter
  parameters:
    comment: 'Audio: 5.5 MHz +/- 100kHz'
    decim: '1'
    gain: '1'
    high_cutoff_freq: sound_carrier+100e3
    low_cutoff_freq: sound_carrier-100e3
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 50e3
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_color
  id: band_pass_filter
  parameters:
    comment: 'Color: 4.43 MHz +/- 500kHz'
    decim: '1'
    gain: '1'
    high_cutoff_freq: color_carrier+500e3
    low_cutoff_freq: color_carrier-500e3
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 200e3
    win: window.WIN_HAMMING
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters:
    comment: AM Demod
  states: {}
- name: blocks_complex_to_mag_color
  id: blocks_complex_to_mag
  parameters:
    comment: Color presence
  states: {}
- name: blocks_multiply_const_audio
  id: blocks_multiply_const_vxx
  parameters:
    const: audio_volume
    type: float
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: demod_mode
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    comment: Remove DC offset
    length: '1024'
    long_form: 'True'
    type: ff
  states: {}
- name: freq_xlating_fir_filter_audio
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: sound_carrier
    comment: Shift audio to baseband
    decim: '1'
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, 100e3, 50e3)
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_1
  id: import
  parameters:
    imports: from gnuradio.filter import firdes
  states: {}
- name: low_pass_filter_video
  id: low_pass_filter
  parameters:
    comment: 'Video: 5 MHz BW'
    cutoff_freq: 5e6
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 0.5e6
    win: window.WIN_HAMMING
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: hackrf=0
    bb_gain0: bb_gain
    freq0: freq
    gain0: rf_gain
    gain_mode0: 'False'
    if_gain0: if_gain
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_audio
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: audio_samp_rate
    color1: '"green"'
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: 3,0,1,2
    label1: Audio
    name: '"Audio Spectrum (5.5 MHz)"'
    type: float
    ymax: '0'
    ymin: '-80'
  states: {}
- name: qtgui_freq_sink_rf
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    grid: 'True'
    gui_hint: 1,0,2,2
    label1: RF Spectrum
    name: '"RF Spectrum"'
    type: complex
    ymax: '0'
    ymin: '-100'
  states: {}
- name: qtgui_time_sink_color
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color1: magenta
    grid: 'True'
    gui_hint: 3,2,1,2
    label1: Color @ 4.43MHz
    name: '"Color Subcarrier (4.43 MHz)"'
    size: '1024'
    srate: samp_rate
    type: float
    ymin: '0'
  states: {}
- name: qtgui_time_sink_video
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: 1,2,2,2
    label1: Video
    name: '"Demodulated Video"'
    size: int(video_samp_rate/15625*2)
    srate: video_samp_rate
    type: float
    update_time: '0.05'
    ymax: '1.5'
    ymin: '-0.5'
  states: {}
- name: rational_resampler_audio
  id: rational_resampler_xxx
  parameters:
    decim: int(samp_rate/audio_samp_rate)
    interp: '1'
    type: fff
  states: {}
- name: rational_resampler_video
  id: rational_resampler_xxx
  parameters:
    decim: int(samp_rate/video_samp_rate)
    interp: '1'
    type: fff
  states: {}

connections:
- [analog_quadrature_demod_audio, '0', rational_resampler_audio, '0']
- [analog_quadrature_demod_cf_0, '0', blocks_selector_0, '1']
- [band_pass_filter_audio, '0', freq_xlating_fir_filter_audio, '0']
- [band_pass_filter_color, '0', blocks_complex_to_mag_color, '0']
- [blocks_complex_to_mag_0, '0', blocks_selector_0, '0']
- [blocks_complex_to_mag_color, '0', qtgui_time_sink_color, '0']
- [blocks_multiply_const_audio, '0', audio_sink_0, '0']
- [blocks_multiply_const_audio, '0', qtgui_freq_sink_audio, '0']
- [blocks_selector_0, '0', dc_blocker_xx_0, '0']
- [dc_blocker_xx_0, '0', rational_resampler_video, '0']
- [freq_xlating_fir_filter_audio, '0', analog_quadrature_demod_audio, '0']
- [low_pass_filter_video, '0', analog_quadrature_demod_cf_0, '0']
- [low_pass_filter_video, '0', blocks_complex_to_mag_0, '0']
- [osmosdr_source_0, '0', band_pass_filter_audio, '0']
- [osmosdr_source_0, '0', band_pass_filter_color, '0']
- [osmosdr_source_0, '0', low_pass_filter_video, '0']
- [osmosdr_source_0, '0', qtgui_freq_sink_rf, '0']
- [rational_resampler_audio, '0', blocks_multiply_const_audio, '0']
- [rational_resampler_video, '0', qtgui_time_sink_video, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
