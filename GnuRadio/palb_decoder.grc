options:
  parameters:
    author: Maren Robotics
    description: PAL-B/G TV Decoder with HackRF
    generate_options: qt_gui
    id: pal_b_decoder_hackrf
    output_language: python
    title: PAL-B/G TV Decoder
  states: {}

blocks:
- name: audio_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,2,1,1
    label: Audio Gain
    start: '0.0'
    step: '0.1'
    stop: '10.0'
    value: '1.0'
  states: {}
- name: audio_rate
  id: variable
  parameters:
    comment: |
      Audio Sample Rate
    value: '48000'
  states: {}
- name: center_freq
  id: variable_qtgui_range
  parameters:
    comment: |-
      Center Frequency
      HackRF: 1 MHz - 6 GHz
    gui_hint: 2,0,1,2
    label: Center Frequency (Hz)
    min_len: '400'
    start: 88e6
    step: '100'
    stop: 900e6
    value: 478e6
  states: {}
- name: demod_mode
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,2,1,1
    label: Demod Mode
    label0: AM
    label1: FM
    num_opts: '2'
    option0: '0'
    option1: '1'
    orient: Qt.QHBoxLayout
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: lna_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: LNA Gain
    rangeType: int
    start: '0'
    step: '8'
    stop: '40'
    value: '40'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: |
      HackRF Sample Rate
    value: 16e6
  states: {}
- name: vga_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,1,1,1
    label: VGA Gain
    rangeType: int
    start: '0'
    step: '2'
    stop: '62'
    value: '20'
  states: {}
- name: video_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: Video Gain
    start: '0.1'
    step: '0.1'
    stop: '10.0'
    value: '1.5'
  states: {}
- name: video_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: Video Offset
    start: '-1.0'
    step: '0.01'
    stop: '1.0'
    value: '0.0'
  states: {}
- name: video_samp_rate
  id: variable
  parameters:
    comment: |
      Video Sample Rate after decimation
    value: 6e6
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    comment: |
      AGC
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: float
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    comment: |
      FM Demodulation
    gain: samp_rate/(2*3.14159*75e3)
  states: {}
- name: analog_quadrature_demod_cf_1
  id: analog_quadrature_demod_cf
  parameters:
    comment: |
      Audio FM Demod
    gain: samp_rate/(2*3.14159*5e3)
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    comment: |-
      Audio Output
      (Speaker)
    samp_rate: audio_rate
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    comment: |
      Video Offset
    const: video_offset
    type: float
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters:
    comment: |
      AM Demodulation
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: |
      Video Gain
    const: video_gain
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    comment: |
      Audio Gain
    const: audio_gain
    type: float
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    comment: |
      AM/FM Selector
    enabled: 'True'
    input_index: demod_mode
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    comment: |
      DC Blocker
    length: '32'
    long_form: 'True'
    type: ff
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    comment: |-
      Video Filter
      5 MHz LPF
    cutoff_freq: 5e6
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: 1e6
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    comment: |-
      Luma Filter
      3 MHz LPF @ 6 MHz
    cutoff_freq: 3e6
    decim: '1'
    gain: '1'
    samp_rate: video_samp_rate
    type: fir_filter_fff
    width: 500e3
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_2
  id: low_pass_filter
  parameters:
    comment: |-
      Audio LPF
      15 kHz
    cutoff_freq: '15000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: hackrf=0
    bb_gain0: vga_gain
    comment: |
      HackRF Source
    freq0: center_freq
    gain0: lna_gain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: center_freq
    fftsize: '1024'
    gui_hint: 3,0,1,2
    name: '"Frequency Spectrum"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 6,0,1,2
    label1: Video
    name: '"Video Signal"'
    size: '1024'
    srate: video_samp_rate
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    gui_hint: 4,0,2,2
    name: '"Waterfall"'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    comment: |-
      Decimate to 6 MHz
      16/3 = 5.33 MHz ~ 6 MHz
    decim: '3'
    interp: '1'
    type: fff
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    comment: |-
      Resample to 48 kHz
      16M → 48k
    decim: '1000'
    interp: '3'
    type: fff
  states: {}

connections:
- [analog_agc_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_quadrature_demod_cf_0, '0', blocks_selector_0, '1']
- [analog_quadrature_demod_cf_1, '0', low_pass_filter_2, '0']
- [blocks_add_const_vxx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_selector_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_multiply_const_vxx_1, '0', audio_sink_0, '0']
- [blocks_selector_0, '0', low_pass_filter_0, '0']
- [dc_blocker_xx_0, '0', rational_resampler_xxx_0, '0']
- [low_pass_filter_0, '0', dc_blocker_xx_0, '0']
- [low_pass_filter_1, '0', analog_agc_xx_0, '0']
- [low_pass_filter_2, '0', rational_resampler_xxx_1, '0']
- [osmosdr_source_0, '0', analog_quadrature_demod_cf_0, '0']
- [osmosdr_source_0, '0', analog_quadrature_demod_cf_1, '0']
- [osmosdr_source_0, '0', blocks_complex_to_mag_0, '0']
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [osmosdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', low_pass_filter_1, '0']
- [rational_resampler_xxx_1, '0', blocks_multiply_const_vxx_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
